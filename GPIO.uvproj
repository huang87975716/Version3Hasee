# Keil uVision project GPIO.uvproj, settings and files
target STM32 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GPIO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\USER;.\FWlib\inc;.\FWlib\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_can.c stm32f10x_adc.c stm32f10x_dma.c
  group USER
    ./USER/: stm32f10x_it.c GPIO.c SysTick.c matrix_motor.c usart.c adc.c PCF8574_I2C.c READ ME.c PtoEtcSW_Check.c main.c timer.c
  group STARTCODE
    ./CMSIS/Startup/: startup_stm32f10x_md.s
